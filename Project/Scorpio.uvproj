# Keil uVision project Scorpio.uvproj, settings and files
target Scorpio (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Scorpio +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Library\inc;..\Kernel\inc;..\Drivers\inc;..\User\inc;..\Cortex-m3\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Cortex-m3
    ../Cortex-m3/src/: core_cm3.c asm.s
  group Kernel
    ../Kernel/src/: startup.c device.c mem.c sem.c stm32f10x_it.c console.c think.c debug.c board.c thread.c schedule.c
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers
    ../Drivers/src/: system_stm32f10x.c USART.c
  group User
    ../User/src/: app.c
